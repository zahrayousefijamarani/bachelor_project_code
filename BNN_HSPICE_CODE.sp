* Memory Simulation

.include 'MTJ_model.inc'

* Memory Simulation

******** cell00 *********
XMTJ00_0 NetBL0_0 Net00_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ00_0 Net00_0 NetWL0 NetSL0 NetSL0 MCH3484 l=45nm w=400um
XMTJ00_1 NetBL0_1 Net00_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ00_1 Net00_1 NetWL0 NetSL0 NetSL0 MCH3484 l=45nm w=400um
**************************

******** cell01 *********
XMTJ01_0 NetBL1_0 Net01_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ01_0 Net01_0 NetWL0 NetSL0 NetSL0 MCH3484 l=45nm w=400um
XMTJ01_1 NetBL1_1 Net01_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ01_1 Net01_1 NetWL0 NetSL0 NetSL0 MCH3484 l=45nm w=400um
**************************

******** cell02 *********
XMTJ02_0 NetBL2_0 Net02_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ02_0 Net02_0 NetWL0 NetSL0 NetSL0 MCH3484 l=45nm w=400um
XMTJ02_1 NetBL2_1 Net02_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ02_1 Net02_1 NetWL0 NetSL0 NetSL0 MCH3484 l=45nm w=400um
**************************

******** cell03 *********
XMTJ03_0 NetBL3_0 Net03_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ03_0 Net03_0 NetWL0 NetSL0 NetSL0 MCH3484 l=45nm w=400um
XMTJ03_1 NetBL3_1 Net03_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ03_1 Net03_1 NetWL0 NetSL0 NetSL0 MCH3484 l=45nm w=400um
**************************

******** cell04 *********
XMTJ04_0 NetBL4_0 Net04_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ04_0 Net04_0 NetWL0 NetSL0 NetSL0 MCH3484 l=45nm w=400um
XMTJ04_1 NetBL4_1 Net04_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ04_1 Net04_1 NetWL0 NetSL0 NetSL0 MCH3484 l=45nm w=400um
**************************

******** cell05 *********
XMTJ05_0 NetBL5_0 Net05_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ05_0 Net05_0 NetWL0 NetSL0 NetSL0 MCH3484 l=45nm w=400um
XMTJ05_1 NetBL5_1 Net05_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ05_1 Net05_1 NetWL0 NetSL0 NetSL0 MCH3484 l=45nm w=400um
**************************

******** cell10 *********
XMTJ10_0 NetBL0_0 Net10_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ10_0 Net10_0 NetWL1 NetSL1 NetSL1 MCH3484 l=45nm w=400um
XMTJ10_1 NetBL0_1 Net10_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ10_1 Net10_1 NetWL1 NetSL1 NetSL1 MCH3484 l=45nm w=400um
**************************

******** cell11 *********
XMTJ11_0 NetBL1_0 Net11_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ11_0 Net11_0 NetWL1 NetSL1 NetSL1 MCH3484 l=45nm w=400um
XMTJ11_1 NetBL1_1 Net11_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ11_1 Net11_1 NetWL1 NetSL1 NetSL1 MCH3484 l=45nm w=400um
**************************

******** cell12 *********
XMTJ12_0 NetBL2_0 Net12_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ12_0 Net12_0 NetWL1 NetSL1 NetSL1 MCH3484 l=45nm w=400um
XMTJ12_1 NetBL2_1 Net12_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ12_1 Net12_1 NetWL1 NetSL1 NetSL1 MCH3484 l=45nm w=400um
**************************

******** cell13 *********
XMTJ13_0 NetBL3_0 Net13_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ13_0 Net13_0 NetWL1 NetSL1 NetSL1 MCH3484 l=45nm w=400um
XMTJ13_1 NetBL3_1 Net13_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ13_1 Net13_1 NetWL1 NetSL1 NetSL1 MCH3484 l=45nm w=400um
**************************

******** cell14 *********
XMTJ14_0 NetBL4_0 Net14_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ14_0 Net14_0 NetWL1 NetSL1 NetSL1 MCH3484 l=45nm w=400um
XMTJ14_1 NetBL4_1 Net14_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ14_1 Net14_1 NetWL1 NetSL1 NetSL1 MCH3484 l=45nm w=400um
**************************

******** cell15 *********
XMTJ15_0 NetBL5_0 Net15_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ15_0 Net15_0 NetWL1 NetSL1 NetSL1 MCH3484 l=45nm w=400um
XMTJ15_1 NetBL5_1 Net15_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ15_1 Net15_1 NetWL1 NetSL1 NetSL1 MCH3484 l=45nm w=400um
**************************

******** cell20 *********
XMTJ20_0 NetBL0_0 Net20_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ20_0 Net20_0 NetWL2 NetSL2 NetSL2 MCH3484 l=45nm w=400um
XMTJ20_1 NetBL0_1 Net20_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ20_1 Net20_1 NetWL2 NetSL2 NetSL2 MCH3484 l=45nm w=400um
**************************

******** cell21 *********
XMTJ21_0 NetBL1_0 Net21_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ21_0 Net21_0 NetWL2 NetSL2 NetSL2 MCH3484 l=45nm w=400um
XMTJ21_1 NetBL1_1 Net21_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ21_1 Net21_1 NetWL2 NetSL2 NetSL2 MCH3484 l=45nm w=400um
**************************

******** cell22 *********
XMTJ22_0 NetBL2_0 Net22_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ22_0 Net22_0 NetWL2 NetSL2 NetSL2 MCH3484 l=45nm w=400um
XMTJ22_1 NetBL2_1 Net22_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ22_1 Net22_1 NetWL2 NetSL2 NetSL2 MCH3484 l=45nm w=400um
**************************

******** cell23 *********
XMTJ23_0 NetBL3_0 Net23_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ23_0 Net23_0 NetWL2 NetSL2 NetSL2 MCH3484 l=45nm w=400um
XMTJ23_1 NetBL3_1 Net23_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ23_1 Net23_1 NetWL2 NetSL2 NetSL2 MCH3484 l=45nm w=400um
**************************

******** cell24 *********
XMTJ24_0 NetBL4_0 Net24_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ24_0 Net24_0 NetWL2 NetSL2 NetSL2 MCH3484 l=45nm w=400um
XMTJ24_1 NetBL4_1 Net24_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ24_1 Net24_1 NetWL2 NetSL2 NetSL2 MCH3484 l=45nm w=400um
**************************

******** cell25 *********
XMTJ25_0 NetBL5_0 Net25_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ25_0 Net25_0 NetWL2 NetSL2 NetSL2 MCH3484 l=45nm w=400um
XMTJ25_1 NetBL5_1 Net25_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ25_1 Net25_1 NetWL2 NetSL2 NetSL2 MCH3484 l=45nm w=400um
**************************

******** cell30 *********
XMTJ30_0 NetBL0_0 Net30_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ30_0 Net30_0 NetWL3 NetSL3 NetSL3 MCH3484 l=45nm w=400um
XMTJ30_1 NetBL0_1 Net30_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ30_1 Net30_1 NetWL3 NetSL3 NetSL3 MCH3484 l=45nm w=400um
**************************

******** cell31 *********
XMTJ31_0 NetBL1_0 Net31_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ31_0 Net31_0 NetWL3 NetSL3 NetSL3 MCH3484 l=45nm w=400um
XMTJ31_1 NetBL1_1 Net31_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ31_1 Net31_1 NetWL3 NetSL3 NetSL3 MCH3484 l=45nm w=400um
**************************

******** cell32 *********
XMTJ32_0 NetBL2_0 Net32_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ32_0 Net32_0 NetWL3 NetSL3 NetSL3 MCH3484 l=45nm w=400um
XMTJ32_1 NetBL2_1 Net32_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ32_1 Net32_1 NetWL3 NetSL3 NetSL3 MCH3484 l=45nm w=400um
**************************

******** cell33 *********
XMTJ33_0 NetBL3_0 Net33_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ33_0 Net33_0 NetWL3 NetSL3 NetSL3 MCH3484 l=45nm w=400um
XMTJ33_1 NetBL3_1 Net33_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ33_1 Net33_1 NetWL3 NetSL3 NetSL3 MCH3484 l=45nm w=400um
**************************

******** cell34 *********
XMTJ34_0 NetBL4_0 Net34_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ34_0 Net34_0 NetWL3 NetSL3 NetSL3 MCH3484 l=45nm w=400um
XMTJ34_1 NetBL4_1 Net34_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ34_1 Net34_1 NetWL3 NetSL3 NetSL3 MCH3484 l=45nm w=400um
**************************

******** cell35 *********
XMTJ35_0 NetBL5_0 Net35_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ35_0 Net35_0 NetWL3 NetSL3 NetSL3 MCH3484 l=45nm w=400um
XMTJ35_1 NetBL5_1 Net35_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ35_1 Net35_1 NetWL3 NetSL3 NetSL3 MCH3484 l=45nm w=400um
**************************

******** cell40 *********
XMTJ40_0 NetBL0_0 Net40_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ40_0 Net40_0 NetWL4 NetSL4 NetSL4 MCH3484 l=45nm w=400um
XMTJ40_1 NetBL0_1 Net40_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ40_1 Net40_1 NetWL4 NetSL4 NetSL4 MCH3484 l=45nm w=400um
**************************

******** cell41 *********
XMTJ41_0 NetBL1_0 Net41_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ41_0 Net41_0 NetWL4 NetSL4 NetSL4 MCH3484 l=45nm w=400um
XMTJ41_1 NetBL1_1 Net41_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ41_1 Net41_1 NetWL4 NetSL4 NetSL4 MCH3484 l=45nm w=400um
**************************

******** cell42 *********
XMTJ42_0 NetBL2_0 Net42_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ42_0 Net42_0 NetWL4 NetSL4 NetSL4 MCH3484 l=45nm w=400um
XMTJ42_1 NetBL2_1 Net42_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ42_1 Net42_1 NetWL4 NetSL4 NetSL4 MCH3484 l=45nm w=400um
**************************

******** cell43 *********
XMTJ43_0 NetBL3_0 Net43_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ43_0 Net43_0 NetWL4 NetSL4 NetSL4 MCH3484 l=45nm w=400um
XMTJ43_1 NetBL3_1 Net43_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ43_1 Net43_1 NetWL4 NetSL4 NetSL4 MCH3484 l=45nm w=400um
**************************

******** cell44 *********
XMTJ44_0 NetBL4_0 Net44_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ44_0 Net44_0 NetWL4 NetSL4 NetSL4 MCH3484 l=45nm w=400um
XMTJ44_1 NetBL4_1 Net44_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ44_1 Net44_1 NetWL4 NetSL4 NetSL4 MCH3484 l=45nm w=400um
**************************

******** cell45 *********
XMTJ45_0 NetBL5_0 Net45_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ45_0 Net45_0 NetWL4 NetSL4 NetSL4 MCH3484 l=45nm w=400um
XMTJ45_1 NetBL5_1 Net45_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ45_1 Net45_1 NetWL4 NetSL4 NetSL4 MCH3484 l=45nm w=400um
**************************

******** cell50 *********
XMTJ50_0 NetBL0_0 Net50_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ50_0 Net50_0 NetWL5 NetSL5 NetSL5 MCH3484 l=45nm w=400um
XMTJ50_1 NetBL0_1 Net50_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ50_1 Net50_1 NetWL5 NetSL5 NetSL5 MCH3484 l=45nm w=400um
**************************

******** cell51 *********
XMTJ51_0 NetBL1_0 Net51_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ51_0 Net51_0 NetWL5 NetSL5 NetSL5 MCH3484 l=45nm w=400um
XMTJ51_1 NetBL1_1 Net51_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ51_1 Net51_1 NetWL5 NetSL5 NetSL5 MCH3484 l=45nm w=400um
**************************

******** cell52 *********
XMTJ52_0 NetBL2_0 Net52_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ52_0 Net52_0 NetWL5 NetSL5 NetSL5 MCH3484 l=45nm w=400um
XMTJ52_1 NetBL2_1 Net52_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ52_1 Net52_1 NetWL5 NetSL5 NetSL5 MCH3484 l=45nm w=400um
**************************

******** cell53 *********
XMTJ53_0 NetBL3_0 Net53_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ53_0 Net53_0 NetWL5 NetSL5 NetSL5 MCH3484 l=45nm w=400um
XMTJ53_1 NetBL3_1 Net53_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ53_1 Net53_1 NetWL5 NetSL5 NetSL5 MCH3484 l=45nm w=400um
**************************

******** cell54 *********
XMTJ54_0 NetBL4_0 Net54_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ54_0 Net54_0 NetWL5 NetSL5 NetSL5 MCH3484 l=45nm w=400um
XMTJ54_1 NetBL4_1 Net54_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ54_1 Net54_1 NetWL5 NetSL5 NetSL5 MCH3484 l=45nm w=400um
**************************

******** cell55 *********
XMTJ55_0 NetBL5_0 Net55_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ55_0 Net55_0 NetWL5 NetSL5 NetSL5 MCH3484 l=45nm w=400um
XMTJ55_1 NetBL5_1 Net55_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ55_1 Net55_1 NetWL5 NetSL5 NetSL5 MCH3484 l=45nm w=400um
**************************

******** cell60 *********
XMTJ60_0 NetBL0_0 Net60_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ60_0 Net60_0 NetWL6 NetSL6 NetSL6 MCH3484 l=45nm w=400um
XMTJ60_1 NetBL0_1 Net60_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ60_1 Net60_1 NetWL6 NetSL6 NetSL6 MCH3484 l=45nm w=400um
**************************

******** cell61 *********
XMTJ61_0 NetBL1_0 Net61_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ61_0 Net61_0 NetWL6 NetSL6 NetSL6 MCH3484 l=45nm w=400um
XMTJ61_1 NetBL1_1 Net61_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ61_1 Net61_1 NetWL6 NetSL6 NetSL6 MCH3484 l=45nm w=400um
**************************

******** cell62 *********
XMTJ62_0 NetBL2_0 Net62_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ62_0 Net62_0 NetWL6 NetSL6 NetSL6 MCH3484 l=45nm w=400um
XMTJ62_1 NetBL2_1 Net62_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ62_1 Net62_1 NetWL6 NetSL6 NetSL6 MCH3484 l=45nm w=400um
**************************

******** cell63 *********
XMTJ63_0 NetBL3_0 Net63_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ63_0 Net63_0 NetWL6 NetSL6 NetSL6 MCH3484 l=45nm w=400um
XMTJ63_1 NetBL3_1 Net63_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ63_1 Net63_1 NetWL6 NetSL6 NetSL6 MCH3484 l=45nm w=400um
**************************

******** cell64 *********
XMTJ64_0 NetBL4_0 Net64_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ64_0 Net64_0 NetWL6 NetSL6 NetSL6 MCH3484 l=45nm w=400um
XMTJ64_1 NetBL4_1 Net64_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ64_1 Net64_1 NetWL6 NetSL6 NetSL6 MCH3484 l=45nm w=400um
**************************

******** cell65 *********
XMTJ65_0 NetBL5_0 Net65_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ65_0 Net65_0 NetWL6 NetSL6 NetSL6 MCH3484 l=45nm w=400um
XMTJ65_1 NetBL5_1 Net65_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ65_1 Net65_1 NetWL6 NetSL6 NetSL6 MCH3484 l=45nm w=400um
**************************

******** cell70 *********
XMTJ70_0 NetBL0_0 Net70_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ70_0 Net70_0 NetWL7 NetSL7 NetSL7 MCH3484 l=45nm w=400um
XMTJ70_1 NetBL0_1 Net70_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ70_1 Net70_1 NetWL7 NetSL7 NetSL7 MCH3484 l=45nm w=400um
**************************

******** cell71 *********
XMTJ71_0 NetBL1_0 Net71_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ71_0 Net71_0 NetWL7 NetSL7 NetSL7 MCH3484 l=45nm w=400um
XMTJ71_1 NetBL1_1 Net71_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ71_1 Net71_1 NetWL7 NetSL7 NetSL7 MCH3484 l=45nm w=400um
**************************

******** cell72 *********
XMTJ72_0 NetBL2_0 Net72_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ72_0 Net72_0 NetWL7 NetSL7 NetSL7 MCH3484 l=45nm w=400um
XMTJ72_1 NetBL2_1 Net72_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ72_1 Net72_1 NetWL7 NetSL7 NetSL7 MCH3484 l=45nm w=400um
**************************

******** cell73 *********
XMTJ73_0 NetBL3_0 Net73_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ73_0 Net73_0 NetWL7 NetSL7 NetSL7 MCH3484 l=45nm w=400um
XMTJ73_1 NetBL3_1 Net73_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ73_1 Net73_1 NetWL7 NetSL7 NetSL7 MCH3484 l=45nm w=400um
**************************

******** cell74 *********
XMTJ74_0 NetBL4_0 Net74_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ74_0 Net74_0 NetWL7 NetSL7 NetSL7 MCH3484 l=45nm w=400um
XMTJ74_1 NetBL4_1 Net74_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ74_1 Net74_1 NetWL7 NetSL7 NetSL7 MCH3484 l=45nm w=400um
**************************

******** cell75 *********
XMTJ75_0 NetBL5_0 Net75_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ75_0 Net75_0 NetWL7 NetSL7 NetSL7 MCH3484 l=45nm w=400um
XMTJ75_1 NetBL5_1 Net75_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ75_1 Net75_1 NetWL7 NetSL7 NetSL7 MCH3484 l=45nm w=400um
**************************

******** cell80 *********
XMTJ80_0 NetBL0_0 Net80_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ80_0 Net80_0 NetWL8 NetSL8 NetSL8 MCH3484 l=45nm w=400um
XMTJ80_1 NetBL0_1 Net80_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ80_1 Net80_1 NetWL8 NetSL8 NetSL8 MCH3484 l=45nm w=400um
**************************

******** cell81 *********
XMTJ81_0 NetBL1_0 Net81_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ81_0 Net81_0 NetWL8 NetSL8 NetSL8 MCH3484 l=45nm w=400um
XMTJ81_1 NetBL1_1 Net81_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ81_1 Net81_1 NetWL8 NetSL8 NetSL8 MCH3484 l=45nm w=400um
**************************

******** cell82 *********
XMTJ82_0 NetBL2_0 Net82_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ82_0 Net82_0 NetWL8 NetSL8 NetSL8 MCH3484 l=45nm w=400um
XMTJ82_1 NetBL2_1 Net82_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ82_1 Net82_1 NetWL8 NetSL8 NetSL8 MCH3484 l=45nm w=400um
**************************

******** cell83 *********
XMTJ83_0 NetBL3_0 Net83_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ83_0 Net83_0 NetWL8 NetSL8 NetSL8 MCH3484 l=45nm w=400um
XMTJ83_1 NetBL3_1 Net83_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ83_1 Net83_1 NetWL8 NetSL8 NetSL8 MCH3484 l=45nm w=400um
**************************

******** cell84 *********
XMTJ84_0 NetBL4_0 Net84_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ84_0 Net84_0 NetWL8 NetSL8 NetSL8 MCH3484 l=45nm w=400um
XMTJ84_1 NetBL4_1 Net84_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ84_1 Net84_1 NetWL8 NetSL8 NetSL8 MCH3484 l=45nm w=400um
**************************

******** cell85 *********
XMTJ85_0 NetBL5_0 Net85_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ85_0 Net85_0 NetWL8 NetSL8 NetSL8 MCH3484 l=45nm w=400um
XMTJ85_1 NetBL5_1 Net85_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ85_1 Net85_1 NetWL8 NetSL8 NetSL8 MCH3484 l=45nm w=400um
**************************

******** cell90 *********
XMTJ90_0 NetBL0_0 Net90_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ90_0 Net90_0 NetWL9 NetSL9 NetSL9 MCH3484 l=45nm w=400um
XMTJ90_1 NetBL0_1 Net90_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ90_1 Net90_1 NetWL9 NetSL9 NetSL9 MCH3484 l=45nm w=400um
**************************

******** cell91 *********
XMTJ91_0 NetBL1_0 Net91_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ91_0 Net91_0 NetWL9 NetSL9 NetSL9 MCH3484 l=45nm w=400um
XMTJ91_1 NetBL1_1 Net91_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ91_1 Net91_1 NetWL9 NetSL9 NetSL9 MCH3484 l=45nm w=400um
**************************

******** cell92 *********
XMTJ92_0 NetBL2_0 Net92_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ92_0 Net92_0 NetWL9 NetSL9 NetSL9 MCH3484 l=45nm w=400um
XMTJ92_1 NetBL2_1 Net92_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ92_1 Net92_1 NetWL9 NetSL9 NetSL9 MCH3484 l=45nm w=400um
**************************

******** cell93 *********
XMTJ93_0 NetBL3_0 Net93_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ93_0 Net93_0 NetWL9 NetSL9 NetSL9 MCH3484 l=45nm w=400um
XMTJ93_1 NetBL3_1 Net93_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ93_1 Net93_1 NetWL9 NetSL9 NetSL9 MCH3484 l=45nm w=400um
**************************

******** cell94 *********
XMTJ94_0 NetBL4_0 Net94_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ94_0 Net94_0 NetWL9 NetSL9 NetSL9 MCH3484 l=45nm w=400um
XMTJ94_1 NetBL4_1 Net94_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ94_1 Net94_1 NetWL9 NetSL9 NetSL9 MCH3484 l=45nm w=400um
**************************

******** cell95 *********
XMTJ95_0 NetBL5_0 Net95_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ95_0 Net95_0 NetWL9 NetSL9 NetSL9 MCH3484 l=45nm w=400um
XMTJ95_1 NetBL5_1 Net95_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ95_1 Net95_1 NetWL9 NetSL9 NetSL9 MCH3484 l=45nm w=400um
**************************

******** cell100 *********
XMTJ100_0 NetBL0_0 Net100_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ100_0 Net100_0 NetWL10 NetSL10 NetSL10 MCH3484 l=45nm w=400um
XMTJ100_1 NetBL0_1 Net100_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ100_1 Net100_1 NetWL10 NetSL10 NetSL10 MCH3484 l=45nm w=400um
**************************

******** cell101 *********
XMTJ101_0 NetBL1_0 Net101_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ101_0 Net101_0 NetWL10 NetSL10 NetSL10 MCH3484 l=45nm w=400um
XMTJ101_1 NetBL1_1 Net101_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ101_1 Net101_1 NetWL10 NetSL10 NetSL10 MCH3484 l=45nm w=400um
**************************

******** cell102 *********
XMTJ102_0 NetBL2_0 Net102_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ102_0 Net102_0 NetWL10 NetSL10 NetSL10 MCH3484 l=45nm w=400um
XMTJ102_1 NetBL2_1 Net102_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ102_1 Net102_1 NetWL10 NetSL10 NetSL10 MCH3484 l=45nm w=400um
**************************

******** cell103 *********
XMTJ103_0 NetBL3_0 Net103_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ103_0 Net103_0 NetWL10 NetSL10 NetSL10 MCH3484 l=45nm w=400um
XMTJ103_1 NetBL3_1 Net103_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ103_1 Net103_1 NetWL10 NetSL10 NetSL10 MCH3484 l=45nm w=400um
**************************

******** cell104 *********
XMTJ104_0 NetBL4_0 Net104_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ104_0 Net104_0 NetWL10 NetSL10 NetSL10 MCH3484 l=45nm w=400um
XMTJ104_1 NetBL4_1 Net104_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ104_1 Net104_1 NetWL10 NetSL10 NetSL10 MCH3484 l=45nm w=400um
**************************

******** cell105 *********
XMTJ105_0 NetBL5_0 Net105_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ105_0 Net105_0 NetWL10 NetSL10 NetSL10 MCH3484 l=45nm w=400um
XMTJ105_1 NetBL5_1 Net105_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ105_1 Net105_1 NetWL10 NetSL10 NetSL10 MCH3484 l=45nm w=400um
**************************

******** cell110 *********
XMTJ110_0 NetBL0_0 Net110_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ110_0 Net110_0 NetWL11 NetSL11 NetSL11 MCH3484 l=45nm w=400um
XMTJ110_1 NetBL0_1 Net110_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ110_1 Net110_1 NetWL11 NetSL11 NetSL11 MCH3484 l=45nm w=400um
**************************

******** cell111 *********
XMTJ111_0 NetBL1_0 Net111_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ111_0 Net111_0 NetWL11 NetSL11 NetSL11 MCH3484 l=45nm w=400um
XMTJ111_1 NetBL1_1 Net111_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ111_1 Net111_1 NetWL11 NetSL11 NetSL11 MCH3484 l=45nm w=400um
**************************

******** cell112 *********
XMTJ112_0 NetBL2_0 Net112_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ112_0 Net112_0 NetWL11 NetSL11 NetSL11 MCH3484 l=45nm w=400um
XMTJ112_1 NetBL2_1 Net112_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ112_1 Net112_1 NetWL11 NetSL11 NetSL11 MCH3484 l=45nm w=400um
**************************

******** cell113 *********
XMTJ113_0 NetBL3_0 Net113_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ113_0 Net113_0 NetWL11 NetSL11 NetSL11 MCH3484 l=45nm w=400um
XMTJ113_1 NetBL3_1 Net113_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ113_1 Net113_1 NetWL11 NetSL11 NetSL11 MCH3484 l=45nm w=400um
**************************

******** cell114 *********
XMTJ114_0 NetBL4_0 Net114_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ114_0 Net114_0 NetWL11 NetSL11 NetSL11 MCH3484 l=45nm w=400um
XMTJ114_1 NetBL4_1 Net114_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ114_1 Net114_1 NetWL11 NetSL11 NetSL11 MCH3484 l=45nm w=400um
**************************

******** cell115 *********
XMTJ115_0 NetBL5_0 Net115_0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ115_0 Net115_0 NetWL11 NetSL11 NetSL11 MCH3484 l=45nm w=400um
XMTJ115_1 NetBL5_1 Net115_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ115_1 Net115_1 NetWL11 NetSL11 NetSL11 MCH3484 l=45nm w=400um
**************************

********** Word Line *********
V0 NetWL0 0 PULSE (0V 0.7V 5us 0us 0us 4.5us 20us)
V1 NetWL1 0 PULSE (0V 0.7V 5us 0us 0us 4.5us 20us)
V2 NetWL2 0 PULSE (0V 0.7V 5us 0us 0us 4.5us 20us)
V3 NetWL3 0 PULSE (0V 0.7V 5us 0us 0us 4.5us 20us)
V4 NetWL4 0 PULSE (0V 0.7V 5us 0us 0us 4.5us 20us)
V5 NetWL5 0 PULSE (0V 0.7V 5us 0us 0us 4.5us 20us)
V6 NetWL6 0 PULSE (0V 0.7V 5us 0us 0us 4.5us 20us)
V7 NetWL7 0 PULSE (0V 0.7V 5us 0us 0us 4.5us 20us)
V8 NetWL8 0 PULSE (0V 0.7V 5us 0us 0us 4.5us 20us)
V9 NetWL9 0 PULSE (0V 0.7V 5us 0us 0us 4.5us 20us)
V10 NetWL10 0 PULSE (0V 0.7V 5us 0us 0us 4.5us 20us)
V11 NetWL11 0 PULSE (0V 0.7V 5us 0us 0us 4.5us 20us)
**************************

********** Bit Line *********
V12_0 NetBL0_0 0 0.3V
V12_1 NetBL0_1 0 0

V13_0 NetBL1_0 0 0.3V
V13_1 NetBL1_1 0 0

V14_0 NetBL2_0 0 0.3V
V14_1 NetBL2_1 0 0

V15_0 NetBL3_0 0 0.3V
V15_1 NetBL3_1 0 0

V16_0 NetBL4_0 0 0.3V
V16_1 NetBL4_1 0 0

V17_0 NetBL5_0 0 0.3V
V17_1 NetBL5_1 0 0

**************************

********** OpAMP *********
E_opamp0 Net_opamp0 0 VCVS NetSL0 Net1016 1E6 max=0.3 min=0

E_opamp1 Net_opamp1 0 VCVS NetSL1 Net1016 1E6 max=0.3 min=0

E_opamp2 Net_opamp2 0 VCVS NetSL2 Net1016 1E6 max=0.3 min=0

E_opamp3 Net_opamp3 0 VCVS NetSL3 Net1016 1E6 max=0.3 min=0

E_opamp4 Net_opamp4 0 VCVS NetSL4 Net1016 1E6 max=0.3 min=0

E_opamp5 Net_opamp5 0 VCVS NetSL5 Net1016 1E6 max=0.3 min=0

E_opamp6 Net_opamp6 0 VCVS NetSL6 Net1016 1E6 max=0.3 min=0

E_opamp7 Net_opamp7 0 VCVS NetSL7 Net1016 1E6 max=0.3 min=0

E_opamp8 Net_opamp8 0 VCVS NetSL8 Net1016 1E6 max=0.3 min=0

E_opamp9 Net_opamp9 0 VCVS NetSL9 Net1016 1E6 max=0.3 min=0

E_opamp10 Net_opamp10 0 VCVS NetSL10 Net1016 1E6 max=0.3 min=0

E_opamp11 Net_opamp11 0 VCVS NetSL11 Net1016 1E6 max=0.3 min=0

**************************

* Memory Simulation

******** cell00 *********
XMTJ00_0_1 NetBL0_0_1 Net00_0_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ00_0_1 Net00_0_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
XMTJ00_1_1 NetBL0_1_1 Net00_1_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ00_1_1 Net00_1_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
**************************

******** cell01 *********
XMTJ01_0_1 NetBL1_0_1 Net01_0_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ01_0_1 Net01_0_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
XMTJ01_1_1 NetBL1_1_1 Net01_1_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ01_1_1 Net01_1_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
**************************

******** cell02 *********
XMTJ02_0_1 NetBL2_0_1 Net02_0_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ02_0_1 Net02_0_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
XMTJ02_1_1 NetBL2_1_1 Net02_1_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ02_1_1 Net02_1_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
**************************

******** cell03 *********
XMTJ03_0_1 NetBL3_0_1 Net03_0_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ03_0_1 Net03_0_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
XMTJ03_1_1 NetBL3_1_1 Net03_1_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ03_1_1 Net03_1_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
**************************

******** cell04 *********
XMTJ04_0_1 NetBL4_0_1 Net04_0_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ04_0_1 Net04_0_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
XMTJ04_1_1 NetBL4_1_1 Net04_1_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ04_1_1 Net04_1_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
**************************

******** cell05 *********
XMTJ05_0_1 NetBL5_0_1 Net05_0_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ05_0_1 Net05_0_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
XMTJ05_1_1 NetBL5_1_1 Net05_1_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ05_1_1 Net05_1_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
**************************

******** cell06 *********
XMTJ06_0_1 NetBL6_0_1 Net06_0_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ06_0_1 Net06_0_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
XMTJ06_1_1 NetBL6_1_1 Net06_1_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ06_1_1 Net06_1_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
**************************

******** cell07 *********
XMTJ07_0_1 NetBL7_0_1 Net07_0_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ07_0_1 Net07_0_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
XMTJ07_1_1 NetBL7_1_1 Net07_1_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ07_1_1 Net07_1_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
**************************

******** cell08 *********
XMTJ08_0_1 NetBL8_0_1 Net08_0_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ08_0_1 Net08_0_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
XMTJ08_1_1 NetBL8_1_1 Net08_1_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ08_1_1 Net08_1_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
**************************

******** cell09 *********
XMTJ09_0_1 NetBL9_0_1 Net09_0_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ09_0_1 Net09_0_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
XMTJ09_1_1 NetBL9_1_1 Net09_1_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ09_1_1 Net09_1_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
**************************

******** cell010 *********
XMTJ010_0_1 NetBL10_0_1 Net010_0_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ010_0_1 Net010_0_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
XMTJ010_1_1 NetBL10_1_1 Net010_1_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ010_1_1 Net010_1_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
**************************

******** cell011 *********
XMTJ011_0_1 NetBL11_0_1 Net011_0_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='0' Kp='1.08e7'
MQ011_0_1 Net011_0_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
XMTJ011_1_1 NetBL11_1_1 Net011_1_1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.62' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
MQ011_1_1 Net011_1_1 NetWL0_1 NetSL0_1 NetSL0_1 MCH3484 l=45nm w=400um
**************************

********** Word Line *********
V0_1_2 NetWL0_1 0 PULSE (0V 0.7V 5us 0us 0us 4.5us 10us)
**************************

********** Bit Line *********
R0_0_1 Net_opamp0 NetBL0_0_1 0.01
MQ0_op0 NetBL0_1_1 Net_opamp0 Net_vdd Net_vdd MCH3383 l=45nm w=400um
MQ0_op1 NetBL0_1_1 Net_opamp0 0 0 MCH3484 l=45nm w=400um

R1_0_1 Net_opamp1 NetBL1_0_1 0.01
MQ1_op0 NetBL1_1_1 Net_opamp1 Net_vdd Net_vdd MCH3383 l=45nm w=400um
MQ1_op1 NetBL1_1_1 Net_opamp1 0 0 MCH3484 l=45nm w=400um

R2_0_1 Net_opamp2 NetBL2_0_1 0.01
MQ2_op0 NetBL2_1_1 Net_opamp2 Net_vdd Net_vdd MCH3383 l=45nm w=400um
MQ2_op1 NetBL2_1_1 Net_opamp2 0 0 MCH3484 l=45nm w=400um

R3_0_1 Net_opamp3 NetBL3_0_1 0.01
MQ3_op0 NetBL3_1_1 Net_opamp3 Net_vdd Net_vdd MCH3383 l=45nm w=400um
MQ3_op1 NetBL3_1_1 Net_opamp3 0 0 MCH3484 l=45nm w=400um

R4_0_1 Net_opamp4 NetBL4_0_1 0.01
MQ4_op0 NetBL4_1_1 Net_opamp4 Net_vdd Net_vdd MCH3383 l=45nm w=400um
MQ4_op1 NetBL4_1_1 Net_opamp4 0 0 MCH3484 l=45nm w=400um

R5_0_1 Net_opamp5 NetBL5_0_1 0.01
MQ5_op0 NetBL5_1_1 Net_opamp5 Net_vdd Net_vdd MCH3383 l=45nm w=400um
MQ5_op1 NetBL5_1_1 Net_opamp5 0 0 MCH3484 l=45nm w=400um

R6_0_1 Net_opamp6 NetBL6_0_1 0.01
MQ6_op0 NetBL6_1_1 Net_opamp6 Net_vdd Net_vdd MCH3383 l=45nm w=400um
MQ6_op1 NetBL6_1_1 Net_opamp6 0 0 MCH3484 l=45nm w=400um

R7_0_1 Net_opamp7 NetBL7_0_1 0.01
MQ7_op0 NetBL7_1_1 Net_opamp7 Net_vdd Net_vdd MCH3383 l=45nm w=400um
MQ7_op1 NetBL7_1_1 Net_opamp7 0 0 MCH3484 l=45nm w=400um

R8_0_1 Net_opamp8 NetBL8_0_1 0.01
MQ8_op0 NetBL8_1_1 Net_opamp8 Net_vdd Net_vdd MCH3383 l=45nm w=400um
MQ8_op1 NetBL8_1_1 Net_opamp8 0 0 MCH3484 l=45nm w=400um

R9_0_1 Net_opamp9 NetBL9_0_1 0.01
MQ9_op0 NetBL9_1_1 Net_opamp9 Net_vdd Net_vdd MCH3383 l=45nm w=400um
MQ9_op1 NetBL9_1_1 Net_opamp9 0 0 MCH3484 l=45nm w=400um

R10_0_1 Net_opamp10 NetBL10_0_1 0.01
MQ10_op0 NetBL10_1_1 Net_opamp10 Net_vdd Net_vdd MCH3383 l=45nm w=400um
MQ10_op1 NetBL10_1_1 Net_opamp10 0 0 MCH3484 l=45nm w=400um

R11_0_1 Net_opamp11 NetBL11_0_1 0.01
MQ11_op0 NetBL11_1_1 Net_opamp11 Net_vdd Net_vdd MCH3383 l=45nm w=400um
MQ11_op1 NetBL11_1_1 Net_opamp11 0 0 MCH3484 l=45nm w=400um

**************************

********** OpAMP *********
E_opamp0_1 Net_opamp0_1 0 VCVS NetSL0_1 Net1016 1E6 max=0.7 min=0

**************************

************ REF ****************
V1_ref Net1016 0 160mv
V_dd Net_vdd 0 0.3V

************ SIMULATION *********
.tran 100ps 15us
*********************************

.model MCH3484 nmos level = 54

+version = 4.0             binunit = 1               paramchk= 1               mobmod  = 0
+capmod  = 2               igcmod  = 1               igbmod  = 1               geomod  = 1
+diomod  = 1               rdsmod  = 0               rbodymod= 1               rgatemod= 1
+permod  = 1               acnqsmod= 0               trnqsmod= 0

+tnom    = 27              toxe    = 9e-010          toxp    = 6.5e-010        toxm    = 9e-010
+dtox    = 2.5e-010        epsrox  = 3.9             wint    = 5e-009          lint    = 2.7e-009
+ll      = 0               wl      = 0               lln     = 1               wln     = 1
+lw      = 0               ww      = 0               lwn     = 1               wwn     = 1
+lwl     = 0               wwl     = 0               xpart   = 0               toxref  = 9e-010           xl      = -20e-9
+dlcig   = 2.7e-009

+vth0    = 0.3424         k1      = 0.2             k2      = 0               k3      = 0
+k3b     = 0               w0      = 2.5e-006        dvt0    = 1               dvt1    = 2
+dvt2    = 0               dvt0w   = 0               dvt1w   = 0               dvt2w   = 0
+dsub    = 0.078           minv    = 0.05            voffl   = 0               dvtp0   = 1e-010
+dvtp1   = 0.1             lpe0    = 0               lpeb    = 0               xj      = 1.4e-008
+ngate   = 1e+023          ndep    = 6.5e+018        nsd     = 2e+020          phin    = 0
+cdsc    = 0               cdscb   = 0               cdscd   = 0               cit     = 0
+voff    = -0.13           nfactor = 1.9             eta0    = 0.0055          etab    = 0
+vfb     = -1.058          u0      = 0.02947         ua      = -5e-010         ub      = 1.7e-018
+uc      = 0               vsat    = 159550          a0      = 1               ags     = 0
+a1      = 0               a2      = 1               b0      = 0               b1      = 0
+keta    = 0.04            dwg     = 0               dwb     = 0               pclm    = 0.06
+pdiblc1 = 0.001           pdiblc2 = 0.001           pdiblcb = -0.005          drout   = 0.5
+pvag    = 1e-020          delta   = 0.01            pscbe1  = 2.0e+009        pscbe2  = 1e-007
+fprout  = 0.2             pdits   = 0.01            pditsd  = 0.23            pditsl  = 2300000
+rsh     = 5               rdsw    = 105             rsw     = 52.5            rdw     = 52.5
+rdswmin = 0               rdwmin  = 0               rswmin  = 0               prwg    = 0
+prwb    = 0               wr      = 1               alpha0  = 0.074           alpha1  = 0.005
+beta0   = 30              agidl   = 0.0002          bgidl   = 2.1e+009        cgidl   = 0.0002
+egidl   = 0.8             aigbacc = 0.012           bigbacc = 0.0028          cigbacc = 0.002
+nigbacc = 1               aigbinv = 0.014           bigbinv = 0.004           cigbinv = 0.004
+eigbinv = 1.1             nigbinv = 3               aigc    = 0.018029        bigc    = 0.0029
+cigc    = 0.002           aigsd   = 0.018029        bigsd   = 0.0029          cigsd   = 0.002
+nigc    = 1               poxedge = 1               pigcd   = 1               ntox    = 1
+xrcrg1  = 12              xrcrg2  = 5

+cgso    = 1e-010          cgdo    = 1e-010          cgbo    = 0               cgdl    = 7.5e-013
+cgsl    = 7.5e-013        clc     = 1e-007          cle     = 0.6             cf      = 1.1e-010
+ckappas = 0.6             ckappad = 0.6             vfbcv   = -1              acde    = 1
+moin    = 15              noff    = 1               voffcv  = 0

+kt1     = -0.154          kt1l    = 0               kt2     = 0.022           ute     = -1.1
+ua1     = 1e-009          ub1     = -1e-018         uc1     = -5.6e-011       prt     = 0
+at      = 33000

+fnoimod = 1               tnoimod = 0               noia    = 6.25e+041       noib    = 3.125e+026
+noic    = 8.75e+009       em      = 41000000        af      = 1               ef      = 1
+kf      = 0               tnoia   = 1.5             tnoib   = 3.5             ntnoi   = 1

+jss     = 1.2e-006        jsws    = 2.4e-013        jswgs   = 2.4e-013        njs     = 1
+ijthsfwd= 0.1             ijthsrev= 0.1             bvs     = 10              xjbvs   = 1
+jsd     = 1.2e-006        jswd    = 2.4e-013        jswgd   = 2.4e-013        xjbvd   = 1
+pbs     = 1               cjs     = 0.0018          mjs     = 0.5             pbsws   = 1
+cjsws   = 1.2e-010        mjsws   = 0.33            cjswgs  = 2.1e-010        cjd     = 0.0018
+cjswd   = 1.2e-010        mjswd   = 0.33            pbswgd  = 1               cjswgd  = 2.1e-010
+mjswgd  = 0.33            tpb     = 0               tcj     = 0               tpbsw   = 0
+tcjsw   = 0               tpbswg  = 0               tcjswg  = 0               xtis    = 3

+dmcg    = 0               dmci    = 0               dmdg    = 0               dmcgt   = 0
+dwj     = 0               xgw     = 0               xgl     = 0

+rshg    = 0.4             gbmin   = 1e-010          rbpb    = 5               rbpd    = 15
+rbps    = 15              rbdb    = 15              rbsb    = 15              ngcon   = 1

* PTM 45nm PMOS

.model MCH3383 pmos level = 54
+version = 4.0             binunit = 1               paramchk= 1               mobmod  = 0
+capmod  = 2               igcmod  = 1               igbmod  = 1               geomod  = 1
+diomod  = 1               rdsmod  = 0               rbodymod= 1               rgatemod= 1
+permod  = 1               acnqsmod= 0               trnqsmod= 0

+tnom    = 27              toxe    = 9.2e-010        toxp    = 6.5e-010        toxm    = 9.2e-010
+dtox    = 2.7e-010        epsrox  = 3.9             wint    = 5e-009          lint    = 2.7e-009
+ll      = 0               wl      = 0               lln     = 1               wln     = 1
+lw      = 0               ww      = 0               lwn     = 1               wwn     = 1
+lwl     = 0               wwl     = 0               xpart   = 0               toxref  = 9.2e-010         xl      = -20e-9
+dlcig   = 2.7e-009

+vth0    = -0.23122       k1      = 0.2             k2      = -0.01           k3      = 0
+k3b     = 0               w0      = 2.5e-006        dvt0    = 1               dvt1    = 2
+dvt2    = -0.032          dvt0w   = 0               dvt1w   = 0               dvt2w   = 0
+dsub    = 0.1             minv    = 0.05            voffl   = 0               dvtp0   = 1e-011
+dvtp1   = 0.05            lpe0    = 0               lpeb    = 0               xj      = 1.4e-008
+ngate   = 1e+023          ndep    = 2.8e+018        nsd     = 2e+020          phin    = 0
+cdsc    = 0               cdscb   = 0               cdscd   = 0               cit     = 0
+voff    = -0.13           nfactor = 1.9             eta0    = 0.0049          etab    = 0
+vfb     = -1.058          u0      = 0.00391         ua      = -5e-010         ub      = 1.6e-018
+uc      = 0               vsat    = 78000           a0      = 1               ags     = 1e-020
+a1      = 0               a2      = 1               b0      = 0               b1      = 0
+keta    = -0.047          dwg     = 0               dwb     = 0               pclm    = 0.1
+pdiblc1 = 0.001           pdiblc2 = 0.001           pdiblcb = 3.4e-008        drout   = 0.6
+pvag    = 1e-020          delta   = 0.01            pscbe1  = 2e+009          pscbe2  = 9.58e-007
+fprout  = 0.2             pdits   = 0.08            pditsd  = 0.23            pditsl  = 2300000
+rsh     = 5               rdsw    = 105             rsw     = 52.5            rdw     = 52.5
+rdswmin = 0               rdwmin  = 0               rswmin  = 0               prwg    = 0
+prwb    = 0               wr      = 1               alpha0  = 0.074           alpha1  = 0.005
+beta0   = 30              agidl   = 0.0002          bgidl   = 2.1e+009        cgidl   = 0.0002
+egidl   = 0.8             aigbacc = 0.012           bigbacc = 0.0028          cigbacc = 0.002
+nigbacc = 1               aigbinv = 0.014           bigbinv = 0.004           cigbinv = 0.004
+eigbinv = 1.1             nigbinv = 3               aigc    = 0.010687        bigc    = 0.0012607
+cigc    = 0.0008          aigsd   = 0.010687        bigsd   = 0.0012607       cigsd   = 0.0008
+nigc    = 1               poxedge = 1               pigcd   = 1               ntox    = 1
+xrcrg1  = 12              xrcrg2  = 5

+cgso    = 1e-010          cgdo    = 1e-010          cgbo    = 0               cgdl    = 3e-011
+cgsl    = 3e-011          clc     = 1e-007          cle     = 0.6             cf      = 1.1e-010
+ckappas = 0.6             ckappad = 0.6             vfbcv   = -1              acde    = 1
+moin    = 15              noff    = 1               voffcv  = 0

+kt1     = -0.14           kt1l    = 0               kt2     = 0.022           ute     = -1.1
+ua1     = 1e-009          ub1     = -1e-018         uc1     = -5.6e-011       prt     = 0
+at      = 33000

+fnoimod = 1               tnoimod = 0               noia    = 6.25e+041       noib    = 3.125e+026
+noic    = 8.75e+009       em      = 41000000        af      = 1               ef      = 1
+kf      = 0               tnoia   = 1.5             tnoib   = 3.5             ntnoi   = 1

+jss     = 2e-007          jsws    = 4e-013          jswgs   = 4e-013          njs     = 1
+ijthsfwd= 0.1             ijthsrev= 0.1             bvs     = 10              xjbvs   = 1
+jsd     = 2e-007          jswd    = 4e-013          jswgd   = 4e-013          xjbvd   = 1
+pbs     = 1               cjs     = 0.0015          mjs     = 0.5             pbsws   = 1
+cjsws   = 9.4e-011        mjsws   = 0.33            cjswgs  = 2e-010          cjd     = 0.0015
+cjswd   = 9.4e-011        mjswd   = 0.33            pbswgd  = 1               cjswgd  = 2e-010
+mjswgd  = 0.33            tpb     = 0               tcj     = 0               tpbsw   = 0
+tcjsw   = 0               tpbswg  = 0               tcjswg  = 0               xtis    = 3

+dmcg    = 0               dmdg    = 0               dmcgt   = 0               xgw     = 0
+xgl     = 0

+rshg    = 0.1             gbmin   = 1e-012          rbpb    = 50              rbpd    = 50
+rbps    = 50              rbdb    = 50              rbsb    = 50              ngcon   = 1

.end
