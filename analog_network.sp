* Memory Simulation

.include 'MTJ_model.inc'

* Memory Simulation

******** cell00 *********
XMTJ00_0 NetBL0_0 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ00_1 NetBL0_1 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.987' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell01 *********
XMTJ01_0 NetBL1_0 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ01_1 NetBL1_1 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.987' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell02 *********
XMTJ02_0 NetBL2_0 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ02_1 NetBL2_1 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell03 *********
XMTJ03_0 NetBL3_0 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ03_1 NetBL3_1 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell04 *********
XMTJ04_0 NetBL4_0 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ04_1 NetBL4_1 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell05 *********
XMTJ05_0 NetBL5_0 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.07' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ05_1 NetBL5_1 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell06 *********
XMTJ06_0 NetBL6_0 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.66' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ06_1 NetBL6_1 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell07 *********
XMTJ07_0 NetBL7_0 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.07' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ07_1 NetBL7_1 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell08 *********
XMTJ08_0 NetBL8_0 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ08_1 NetBL8_1 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell09 *********
XMTJ09_0 NetBL9_0 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ09_1 NetBL9_1 NetSL0 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell10 *********
XMTJ10_0 NetBL0_0 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ10_1 NetBL0_1 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.07' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell11 *********
XMTJ11_0 NetBL1_0 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.56' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ11_1 NetBL1_1 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell12 *********
XMTJ12_0 NetBL2_0 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ12_1 NetBL2_1 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell13 *********
XMTJ13_0 NetBL3_0 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ13_1 NetBL3_1 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell14 *********
XMTJ14_0 NetBL4_0 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ14_1 NetBL4_1 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell15 *********
XMTJ15_0 NetBL5_0 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ15_1 NetBL5_1 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.07' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell16 *********
XMTJ16_0 NetBL6_0 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ16_1 NetBL6_1 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.07' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell17 *********
XMTJ17_0 NetBL7_0 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ17_1 NetBL7_1 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.07' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell18 *********
XMTJ18_0 NetBL8_0 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ18_1 NetBL8_1 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.07' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell19 *********
XMTJ19_0 NetBL9_0 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ19_1 NetBL9_1 NetSL1 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.07' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell20 *********
XMTJ20_0 NetBL0_0 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.66' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ20_1 NetBL0_1 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell21 *********
XMTJ21_0 NetBL1_0 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ21_1 NetBL1_1 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.07' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell22 *********
XMTJ22_0 NetBL2_0 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ22_1 NetBL2_1 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.07' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell23 *********
XMTJ23_0 NetBL3_0 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ23_1 NetBL3_1 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.07' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell24 *********
XMTJ24_0 NetBL4_0 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ24_1 NetBL4_1 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.07' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell25 *********
XMTJ25_0 NetBL5_0 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.91' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ25_1 NetBL5_1 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell26 *********
XMTJ26_0 NetBL6_0 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ26_1 NetBL6_1 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.75' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell27 *********
XMTJ27_0 NetBL7_0 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ27_1 NetBL7_1 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.91' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell28 *********
XMTJ28_0 NetBL8_0 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ28_1 NetBL8_1 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell29 *********
XMTJ29_0 NetBL9_0 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ29_1 NetBL9_1 NetSL2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell30 *********
XMTJ30_0 NetBL0_0 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ30_1 NetBL0_1 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.83' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell31 *********
XMTJ31_0 NetBL1_0 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ31_1 NetBL1_1 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.91' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell32 *********
XMTJ32_0 NetBL2_0 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ32_1 NetBL2_1 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell33 *********
XMTJ33_0 NetBL3_0 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ33_1 NetBL3_1 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.07' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell34 *********
XMTJ34_0 NetBL4_0 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ34_1 NetBL4_1 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.07' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell35 *********
XMTJ35_0 NetBL5_0 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.83' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ35_1 NetBL5_1 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell36 *********
XMTJ36_0 NetBL6_0 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.987' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ36_1 NetBL6_1 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell37 *********
XMTJ37_0 NetBL7_0 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.987' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ37_1 NetBL7_1 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell38 *********
XMTJ38_0 NetBL8_0 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ38_1 NetBL8_1 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell39 *********
XMTJ39_0 NetBL9_0 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ39_1 NetBL9_1 NetSL3 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

********** Sense Line *********
H_opamp0 Net_opamp0 0 CCVS V_ref0 1E6 max=0.3 min=0
V_ref0 NetSL0 0 0
H_opamp1 Net_opamp1 0 CCVS V_ref1 1E6 max=0.3 min=0
V_ref1 NetSL1 0 0
H_opamp2 Net_opamp2 0 CCVS V_ref2 1E6 max=0.3 min=0
V_ref2 NetSL2 0 0
H_opamp3 Net_opamp3 0 CCVS V_ref3 1E6 max=0.3 min=0
V_ref3 NetSL3 0 0
**************************

********** Bit Line *********
V4_0 NetBL0_0 0 PULSE (0V 0.3V 5us 0.5us 0.5us 4.5us 10us)
V4_1 NetBL0_1 0 PULSE (0V -0.3V 5us 0.5us 0.5us 4.5us 10us)

V5_0 NetBL1_0 0 PULSE (0V 0.3V 5us 0.5us 0.5us 4.5us 10us)
V5_1 NetBL1_1 0 PULSE (0V -0.3V 5us 0.5us 0.5us 4.5us 10us)

V6_0 NetBL2_0 0 PULSE (0V 0.3V 5us 0.5us 0.5us 4.5us 10us)
V6_1 NetBL2_1 0 PULSE (0V -0.3V 5us 0.5us 0.5us 4.5us 10us)

V7_0 NetBL3_0 0 PULSE (0V 0.3V 5us 0.5us 0.5us 4.5us 10us)
V7_1 NetBL3_1 0 PULSE (0V -0.3V 5us 0.5us 0.5us 4.5us 10us)

V8_0 NetBL4_0 0 PULSE (0V 0.3V 5us 0.5us 0.5us 4.5us 10us)
V8_1 NetBL4_1 0 PULSE (0V -0.3V 5us 0.5us 0.5us 4.5us 10us)

V9_0 NetBL5_0 0 PULSE (0V 0.3V 5us 0.5us 0.5us 4.5us 10us)
V9_1 NetBL5_1 0 PULSE (0V -0.3V 5us 0.5us 0.5us 4.5us 10us)

V10_0 NetBL6_0 0 PULSE (0V 0.3V 5us 0.5us 0.5us 4.5us 10us)
V10_1 NetBL6_1 0 PULSE (0V -0.3V 5us 0.5us 0.5us 4.5us 10us)

V11_0 NetBL7_0 0 PULSE (0V 0.3V 5us 0.5us 0.5us 4.5us 10us)
V11_1 NetBL7_1 0 PULSE (0V -0.3V 5us 0.5us 0.5us 4.5us 10us)

V12_0 NetBL8_0 0 PULSE (0V 0.3V 5us 0.5us 0.5us 4.5us 10us)
V12_1 NetBL8_1 0 PULSE (0V -0.3V 5us 0.5us 0.5us 4.5us 10us)

V13_0 NetBL9_0 0 PULSE (0V 0.3V 5us 0.5us 0.5us 4.5us 10us)
V13_1 NetBL9_1 0 PULSE (0V -0.3V 5us 0.5us 0.5us 4.5us 10us)

**************************

* Memory Simulation

******** cell00_2 *********
XMTJ00_0_2 NetBL0_0_2 NetSL0_2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.83' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ00_1_2 NetBL0_1_2 NetSL0_2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell01_2 *********
XMTJ01_0_2 NetBL1_0_2 NetSL0_2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.75' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ01_1_2 NetBL1_1_2 NetSL0_2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell02_2 *********
XMTJ02_0_2 NetBL2_0_2 NetSL0_2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.83' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ02_1_2 NetBL2_1_2 NetSL0_2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

******** cell03_2 *********
XMTJ03_0_2 NetBL3_0_2 NetSL0_2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='0.91' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
XMTJ03_1_2 NetBL3_1_2 NetSL0_2 MTJ lx='40n' ly='116n' lz='1.5n' tox='1.15n' Ms0='850' P0='1.15' alpha='0.028' Tmp0='358' RA0='5' MA='1' ini='1' Kp='1.08e7'
**************************

********** Sense Line *********
*VIPROBE0_0_2 NetSL_a0_2 0 DC 0
*MQ_SL0 NetSL0_2 Net_gate0 NetSL_a0_2 NetSL_a0_2 MCH3484 l=45nm w=400um
*V_sl0 Net_gate0 0 1V
**************************

H_opamp10 Net_opamp10 0 CCVS V_ref10 1E6 max=0.3 min=0
V_ref10 NetSL0_2 0 0

********** Bit Line *********
R_SL0 Net_opamp0 NetBL0_0_2 0.01
MQ0_op0_0 NetBL0_1_2 Net_opamp0 Net_vdd Net_vdd MCH3383 l=45nm w=400um
MQ0_op0_1 NetBL0_1_2 Net_opamp0 Net_g Net_g MCH3484 l=45nm w=400um

R_SL1 Net_opamp1 NetBL1_0_2 0.01
MQ0_op1_0 NetBL1_1_2 Net_opamp1 Net_vdd Net_vdd MCH3383 l=45nm w=400um
MQ0_op1_1 NetBL1_1_2 Net_opamp1 Net_g Net_g MCH3484 l=45nm w=400um

R_SL2 Net_opamp2 NetBL2_0_2 0.01
MQ0_op2_0 NetBL2_1_2 Net_opamp2 Net_vdd Net_vdd MCH3383 l=45nm w=400um
MQ0_op2_1 NetBL2_1_2 Net_opamp2 Net_g Net_g MCH3484 l=45nm w=400um

R_SL3 Net_opamp3 NetBL3_0_2 0.01
MQ0_op3_0 NetBL3_1_2 Net_opamp3 Net_vdd Net_vdd MCH3383 l=45nm w=400um
MQ0_op3_1 NetBL3_1_2 Net_opamp3 Net_g Net_g MCH3484 l=45nm w=400um

**************************

************ REF ****************
V_dd Net_vdd 0 0.3V
V_g Net_g 0 -0.3V

************ SIMULATION *********
.tran 1us 10us
*********************************

.model MCH3484 nmos level = 54

+version = 4.0             binunit = 1               paramchk= 1               mobmod  = 0
+capmod  = 2               igcmod  = 1               igbmod  = 1               geomod  = 1
+diomod  = 1               rdsmod  = 0               rbodymod= 1               rgatemod= 1
+permod  = 1               acnqsmod= 0               trnqsmod= 0

+tnom    = 27              toxe    = 9e-010          toxp    = 6.5e-010        toxm    = 9e-010
+dtox    = 2.5e-010        epsrox  = 3.9             wint    = 5e-009          lint    = 2.7e-009
+ll      = 0               wl      = 0               lln     = 1               wln     = 1
+lw      = 0               ww      = 0               lwn     = 1               wwn     = 1
+lwl     = 0               wwl     = 0               xpart   = 0               toxref  = 9e-010           xl      = -20e-9
+dlcig   = 2.7e-009

+vth0    = 0.3424         k1      = 0.2             k2      = 0               k3      = 0
+k3b     = 0               w0      = 2.5e-006        dvt0    = 1               dvt1    = 2
+dvt2    = 0               dvt0w   = 0               dvt1w   = 0               dvt2w   = 0
+dsub    = 0.078           minv    = 0.05            voffl   = 0               dvtp0   = 1e-010
+dvtp1   = 0.1             lpe0    = 0               lpeb    = 0               xj      = 1.4e-008
+ngate   = 1e+023          ndep    = 6.5e+018        nsd     = 2e+020          phin    = 0
+cdsc    = 0               cdscb   = 0               cdscd   = 0               cit     = 0
+voff    = -0.13           nfactor = 1.9             eta0    = 0.0055          etab    = 0
+vfb     = -1.058          u0      = 0.02947         ua      = -5e-010         ub      = 1.7e-018
+uc      = 0               vsat    = 159550          a0      = 1               ags     = 0
+a1      = 0               a2      = 1               b0      = 0               b1      = 0
+keta    = 0.04            dwg     = 0               dwb     = 0               pclm    = 0.06
+pdiblc1 = 0.001           pdiblc2 = 0.001           pdiblcb = -0.005          drout   = 0.5
+pvag    = 1e-020          delta   = 0.01            pscbe1  = 2.0e+009        pscbe2  = 1e-007
+fprout  = 0.2             pdits   = 0.01            pditsd  = 0.23            pditsl  = 2300000
+rsh     = 5               rdsw    = 105             rsw     = 52.5            rdw     = 52.5
+rdswmin = 0               rdwmin  = 0               rswmin  = 0               prwg    = 0
+prwb    = 0               wr      = 1               alpha0  = 0.074           alpha1  = 0.005
+beta0   = 30              agidl   = 0.0002          bgidl   = 2.1e+009        cgidl   = 0.0002
+egidl   = 0.8             aigbacc = 0.012           bigbacc = 0.0028          cigbacc = 0.002
+nigbacc = 1               aigbinv = 0.014           bigbinv = 0.004           cigbinv = 0.004
+eigbinv = 1.1             nigbinv = 3               aigc    = 0.018029        bigc    = 0.0029
+cigc    = 0.002           aigsd   = 0.018029        bigsd   = 0.0029          cigsd   = 0.002
+nigc    = 1               poxedge = 1               pigcd   = 1               ntox    = 1
+xrcrg1  = 12              xrcrg2  = 5

+cgso    = 1e-010          cgdo    = 1e-010          cgbo    = 0               cgdl    = 7.5e-013
+cgsl    = 7.5e-013        clc     = 1e-007          cle     = 0.6             cf      = 1.1e-010
+ckappas = 0.6             ckappad = 0.6             vfbcv   = -1              acde    = 1
+moin    = 15              noff    = 1               voffcv  = 0

+kt1     = -0.154          kt1l    = 0               kt2     = 0.022           ute     = -1.1
+ua1     = 1e-009          ub1     = -1e-018         uc1     = -5.6e-011       prt     = 0
+at      = 33000

+fnoimod = 1               tnoimod = 0               noia    = 6.25e+041       noib    = 3.125e+026
+noic    = 8.75e+009       em      = 41000000        af      = 1               ef      = 1
+kf      = 0               tnoia   = 1.5             tnoib   = 3.5             ntnoi   = 1

+jss     = 1.2e-006        jsws    = 2.4e-013        jswgs   = 2.4e-013        njs     = 1
+ijthsfwd= 0.1             ijthsrev= 0.1             bvs     = 10              xjbvs   = 1
+jsd     = 1.2e-006        jswd    = 2.4e-013        jswgd   = 2.4e-013        xjbvd   = 1
+pbs     = 1               cjs     = 0.0018          mjs     = 0.5             pbsws   = 1
+cjsws   = 1.2e-010        mjsws   = 0.33            cjswgs  = 2.1e-010        cjd     = 0.0018
+cjswd   = 1.2e-010        mjswd   = 0.33            pbswgd  = 1               cjswgd  = 2.1e-010
+mjswgd  = 0.33            tpb     = 0               tcj     = 0               tpbsw   = 0
+tcjsw   = 0               tpbswg  = 0               tcjswg  = 0               xtis    = 3

+dmcg    = 0               dmci    = 0               dmdg    = 0               dmcgt   = 0
+dwj     = 0               xgw     = 0               xgl     = 0

+rshg    = 0.4             gbmin   = 1e-010          rbpb    = 5               rbpd    = 15
+rbps    = 15              rbdb    = 15              rbsb    = 15              ngcon   = 1

* PTM 45nm PMOS

.model MCH3383 pmos level = 54
+version = 4.0             binunit = 1               paramchk= 1               mobmod  = 0
+capmod  = 2               igcmod  = 1               igbmod  = 1               geomod  = 1
+diomod  = 1               rdsmod  = 0               rbodymod= 1               rgatemod= 1
+permod  = 1               acnqsmod= 0               trnqsmod= 0

+tnom    = 27              toxe    = 9.2e-010        toxp    = 6.5e-010        toxm    = 9.2e-010
+dtox    = 2.7e-010        epsrox  = 3.9             wint    = 5e-009          lint    = 2.7e-009
+ll      = 0               wl      = 0               lln     = 1               wln     = 1
+lw      = 0               ww      = 0               lwn     = 1               wwn     = 1
+lwl     = 0               wwl     = 0               xpart   = 0               toxref  = 9.2e-010         xl      = -20e-9
+dlcig   = 2.7e-009

+vth0    = -0.23122       k1      = 0.2             k2      = -0.01           k3      = 0
+k3b     = 0               w0      = 2.5e-006        dvt0    = 1               dvt1    = 2
+dvt2    = -0.032          dvt0w   = 0               dvt1w   = 0               dvt2w   = 0
+dsub    = 0.1             minv    = 0.05            voffl   = 0               dvtp0   = 1e-011
+dvtp1   = 0.05            lpe0    = 0               lpeb    = 0               xj      = 1.4e-008
+ngate   = 1e+023          ndep    = 2.8e+018        nsd     = 2e+020          phin    = 0
+cdsc    = 0               cdscb   = 0               cdscd   = 0               cit     = 0
+voff    = -0.13           nfactor = 1.9             eta0    = 0.0049          etab    = 0
+vfb     = -1.058          u0      = 0.00391         ua      = -5e-010         ub      = 1.6e-018
+uc      = 0               vsat    = 78000           a0      = 1               ags     = 1e-020
+a1      = 0               a2      = 1               b0      = 0               b1      = 0
+keta    = -0.047          dwg     = 0               dwb     = 0               pclm    = 0.1
+pdiblc1 = 0.001           pdiblc2 = 0.001           pdiblcb = 3.4e-008        drout   = 0.6
+pvag    = 1e-020          delta   = 0.01            pscbe1  = 2e+009          pscbe2  = 9.58e-007
+fprout  = 0.2             pdits   = 0.08            pditsd  = 0.23            pditsl  = 2300000
+rsh     = 5               rdsw    = 105             rsw     = 52.5            rdw     = 52.5
+rdswmin = 0               rdwmin  = 0               rswmin  = 0               prwg    = 0
+prwb    = 0               wr      = 1               alpha0  = 0.074           alpha1  = 0.005
+beta0   = 30              agidl   = 0.0002          bgidl   = 2.1e+009        cgidl   = 0.0002
+egidl   = 0.8             aigbacc = 0.012           bigbacc = 0.0028          cigbacc = 0.002
+nigbacc = 1               aigbinv = 0.014           bigbinv = 0.004           cigbinv = 0.004
+eigbinv = 1.1             nigbinv = 3               aigc    = 0.010687        bigc    = 0.0012607
+cigc    = 0.0008          aigsd   = 0.010687        bigsd   = 0.0012607       cigsd   = 0.0008
+nigc    = 1               poxedge = 1               pigcd   = 1               ntox    = 1
+xrcrg1  = 12              xrcrg2  = 5

+cgso    = 1e-010          cgdo    = 1e-010          cgbo    = 0               cgdl    = 3e-011
+cgsl    = 3e-011          clc     = 1e-007          cle     = 0.6             cf      = 1.1e-010
+ckappas = 0.6             ckappad = 0.6             vfbcv   = -1              acde    = 1
+moin    = 15              noff    = 1               voffcv  = 0

+kt1     = -0.14           kt1l    = 0               kt2     = 0.022           ute     = -1.1
+ua1     = 1e-009          ub1     = -1e-018         uc1     = -5.6e-011       prt     = 0
+at      = 33000

+fnoimod = 1               tnoimod = 0               noia    = 6.25e+041       noib    = 3.125e+026
+noic    = 8.75e+009       em      = 41000000        af      = 1               ef      = 1
+kf      = 0               tnoia   = 1.5             tnoib   = 3.5             ntnoi   = 1

+jss     = 2e-007          jsws    = 4e-013          jswgs   = 4e-013          njs     = 1
+ijthsfwd= 0.1             ijthsrev= 0.1             bvs     = 10              xjbvs   = 1
+jsd     = 2e-007          jswd    = 4e-013          jswgd   = 4e-013          xjbvd   = 1
+pbs     = 1               cjs     = 0.0015          mjs     = 0.5             pbsws   = 1
+cjsws   = 9.4e-011        mjsws   = 0.33            cjswgs  = 2e-010          cjd     = 0.0015
+cjswd   = 9.4e-011        mjswd   = 0.33            pbswgd  = 1               cjswgd  = 2e-010
+mjswgd  = 0.33            tpb     = 0               tcj     = 0               tpbsw   = 0
+tcjsw   = 0               tpbswg  = 0               tcjswg  = 0               xtis    = 3

+dmcg    = 0               dmdg    = 0               dmcgt   = 0               xgw     = 0
+xgl     = 0

+rshg    = 0.1             gbmin   = 1e-012          rbpb    = 50              rbpd    = 50
+rbps    = 50              rbdb    = 50              rbsb    = 50              ngcon   = 1

.end
